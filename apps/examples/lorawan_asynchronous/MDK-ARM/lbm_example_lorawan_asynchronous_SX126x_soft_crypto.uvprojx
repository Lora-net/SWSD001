# Keil uVision project lbm_example_lorawan_asynchronous_SX126x_soft_crypto.uvprojx, settings and files
target SX1261MB1BAS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lbm_example_lorawan_asynchronous +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: ADD_SMTC_ALC_SYNC,ADD_SMTC_FILE_UPLOAD,ADD_SMTC_STREAM,HAL_DBG_TRACE=1,MODEM_HAL_DBG_TRACE=1,MODEM_HAL_DEEP_DBG_TRACE=0,NUCLEO_L476RG,REGION_AS_923,REGION_AU_915,REGION_CN_470,REGION_CN_470_RP_1_0,REGION_EU_868,REGION_IN_865,REGION_KR_920,REGION_RU_864,REGION_US_915,RP2_103,SMTC_MULTICAST,STM32L476xx,SX126X,USER_DEFINED_JOIN_PARAMETERS,USE_FULL_LL_DRIVER,USE_HAL_DRIVER
  c include: ..\..\..\..\apps\common;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Include;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\hal_config;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_api\;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\device_management;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_b;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_c;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\smtc_real\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_config;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_supervisor;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\sx126x_driver\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\sx126x_driver\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_planner\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\smtc_secure_element;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\soft_secure_element;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\headers;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\alc_sync;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\file_upload;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\stream;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ral\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ralf\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal\;..\..\..\..\lora_basics_modem\printers\;..\..\..\..\shields\SX126X\common\inc;..\..\..\..\shields\SX126X\radio_drivers_hal;..\..\..\..\shields\SX126X\smtc_shield_sx126x\SX1261MB1BAS\inc;..\..\..\..\shields\SX126X\smtc_shield_sx126x\common\inc;..\..\..\..\shields\common;..\..\..\..\shields\interface;..\..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\inc;..\..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\smtc_modem_hal\;..\..\..\..\smtc_hal\board\;..\..\..\..\smtc_hal\inc\;..\..\..\..\lora_basics_modem\lora_basics_modem;..\..\..\..\shields\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ../../../../host_driver/STMicroelectronics/STM32L4xx/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l476xx.s
  group Application/User
    ../../../common/: apps_utilities.c apps_modem_common.c apps_modem_event.c
    ../: main_lorawan_asynchronous.c
    ../../../../lora_basics_modem/printers/: smtc_modem_api_str.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../host_driver/STMicroelectronics/STM32L4xx/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rng.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_lptim.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_iwdg.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../../../../host_driver/STMicroelectronics/STM32L4xx/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/BSP/Components
    ../../../../shields/common/: usr_button.c
  group radio_driver
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/radio_drivers/sx126x_driver/src/: lr_fhss_mac.c sx126x.c sx126x_lr_fhss.c
  group smtc_modem_hal
    ../../../../smtc_hal/STMicroelectronics/STM32L4xx/smtc_modem_hal/: smtc_modem_hal.c
  group smtc_hal
    ../../../../smtc_hal/STMicroelectronics/STM32L4xx/src/: smtc_hal_adc.c smtc_hal_flash.c smtc_hal_gpio.c smtc_hal_i2c.c smtc_hal_lp_timer.c smtc_hal_mcu.c smtc_hal_rng.c smtc_hal_rtc.c smtc_hal_spi.c smtc_hal_tmr_list.c smtc_hal_trace.c smtc_hal_uart.c smtc_hal_watchdog.c
  group radio_hal
    ../../../../shields/SX126X/radio_drivers_hal/: sx126x_hal.c
  group radio_ral
    ../../../../shields/SX126X/common/src/: ral_sx126x_bsp.c
  group smtc_modem_services
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_modem_services/src/alc_sync/: alc_sync.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_modem_services/src/file_upload/: file_upload.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_modem_services/src/stream/: rose.c stream.c
  group smtc_ral
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_ral/src/: ral_sx126x.c
  group smtc_ralf
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_ralf/src/: ralf_sx126x.c
  group smtc_modem_crypto
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_modem_crypto/: smtc_modem_crypto.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_modem_crypto/soft_secure_element/: cmac.c soft_se.c aes.c
  group smtc_modem_core
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/lorawan_api/: lorawan_api.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/device_management/: dm_downlink.c modem_context.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/modem_core/: smtc_modem.c smtc_modem_test.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/modem_services/: fifo_ctrl.c lorawan_certification.c modem_utilities.c smtc_modem_services_hal.c smtc_clock_sync.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/modem_supervisor/: modem_supervisor.c
  group lr1mac
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/lr1mac/src/: lr1_stack_mac_layer.c lr1mac_core.c lr1mac_utilities.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/lr1mac/src/smtc_real/src/: smtc_real.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/lr1mac/src/services/: smtc_duty_cycle.c smtc_lbt.c smtc_multicast.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/lr1mac/src/lr1mac_class_c/: lr1mac_class_c.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/lr1mac/src/lr1mac_class_b/: smtc_beacon_sniff.c smtc_ping_slot.c
  group radio_planner
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/radio_planner/src/: radio_planner.c radio_planner_hal.c
  group smtc_region
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/lr1mac/src/smtc_real/src/: region_eu_868.c region_cn_470.c region_cn_470_rp_1_0.c region_us_915.c region_as_923.c region_au_915.c region_in_865.c region_kr_920.c region_ru_864.c
  group shields
    ../../../../shields/SX126X/smtc_shield_sx126x/SX1261MB1BAS/src/: smtc_shield_sx1261mb1bas.c
    ../../../../shields/SX126X/smtc_shield_sx126x/SX1261MB1CAS/src/: smtc_shield_sx1261mb1cas.c
    ../../../../shields/SX126X/smtc_shield_sx126x/SX1261MB2BAS/src/: smtc_shield_sx1261mb2bas.c
    ../../../../shields/SX126X/smtc_shield_sx126x/SX1262MB1CAS/src/: smtc_shield_sx1262mb1cas.c
    ../../../../shields/SX126X/smtc_shield_sx126x/SX1262MB1CBS/src/: smtc_shield_sx1262mb1cbs.c
    ../../../../shields/SX126X/smtc_shield_sx126x/SX1262MB1DAS/src/: smtc_shield_sx1262mb1das.c
    ../../../../shields/SX126X/smtc_shield_sx126x/SX1262MB1PAS/src/: smtc_shield_sx1262mb1pas.c
    ../../../../shields/SX126X/smtc_shield_sx126x/SX1262MB2CAS/src/: smtc_shield_sx1262mb2cas.c
    ../../../../shields/SX126X/smtc_shield_sx126x/SX1268MB1GAS/src/: smtc_shield_sx1268mb1gas.c
    ../../../../shields/SX126X/smtc_shield_sx126x/common/src/: smtc_shield_sx126x_led.c smtc_shield_sx126x_ant_sw.c
  group board
    ../../../../shields/SX126X/common/src/: smtc_board_sx126x.c
target SX1261MB1CAS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: lbm_example_lorawan_asynchronous +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: as above
  c include: ..\..\..\..\apps\common;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Include;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\hal_config;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_api\;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\device_management;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_b;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_c;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\smtc_real\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_config;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_supervisor;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\sx126x_driver\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\sx126x_driver\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_planner\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\smtc_secure_element;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\soft_secure_element;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\headers;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\alc_sync;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\file_upload;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\stream;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ral\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ralf\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal\;..\..\..\..\lora_basics_modem\printers\;..\..\..\..\shields\SX126X\common\inc;..\..\..\..\shields\SX126X\radio_drivers_hal;..\..\..\..\shields\SX126X\smtc_shield_sx126x\SX1261MB1BAS\inc;..\..\..\..\shields\SX126X\smtc_shield_sx126x\common\inc;..\..\..\..\shields\common;..\..\..\..\shields\interface;..\..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\inc;..\..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\smtc_modem_hal\;..\..\..\..\smtc_hal\board\;..\..\..\..\smtc_hal\inc\;..\..\..\..\lora_basics_modem\lora_basics_modem;..\..\..\..\shields\SX126X\smtc_shield_sx126x\SX1261MB1CAS\inc;..\..\..\..\shields\SX126X\smtc_shield_sx126x\SX1261MB2BAS\inc;..\..\..\..\shields\SX126X\smtc_shield_sx126x\SX1262MB1CAS\inc;..\..\..\..\shields\SX126X\smtc_shield_sx126x\SX1262MB1CBS\inc;..\..\..\..\shields\SX126X\smtc_shield_sx126x\SX1262MB1DAS\inc;..\..\..\..\shields\SX126X\smtc_shield_sx126x\SX1262MB1PAS\inc;..\..\..\..\shields\SX126X\smtc_shield_sx126x\SX1262MB2CAS\inc;..\..\..\..\shields\SX126X\smtc_shield_sx126x\SX1268MB1GAS\inc;..\..\..\..\shields\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target SX1261MB2BAS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: lbm_example_lorawan_asynchronous +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: as above
  c include: ..\..\..\..\apps\common;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Include;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\hal_config;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_api\;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\device_management;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_b;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_c;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\smtc_real\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_config;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_supervisor;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\sx126x_driver\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\sx126x_driver\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_planner\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\smtc_secure_element;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\soft_secure_element;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\headers;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\alc_sync;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\file_upload;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\stream;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ral\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ralf\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal\;..\..\..\..\lora_basics_modem\printers\;..\..\..\..\shields\SX126X\common\inc;..\..\..\..\shields\SX126X\radio_drivers_hal;..\..\..\..\shields\SX126X\smtc_shield_sx126x\SX1261MB2BAS\inc;..\..\..\..\shields\SX126X\smtc_shield_sx126x\common\inc;..\..\..\..\shields\common;..\..\..\..\shields\interface;..\..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\inc;..\..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\smtc_modem_hal\;..\..\..\..\smtc_hal\board\;..\..\..\..\smtc_hal\inc\;..\..\..\..\lora_basics_modem\lora_basics_modem;..\..\..\..\shields\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target SX1262MB1CAS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: lbm_example_lorawan_asynchronous +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: as above
  c include: ..\..\..\..\apps\common;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Include;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\hal_config;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_api\;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\device_management;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_b;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_c;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\smtc_real\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_config;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_supervisor;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\sx126x_driver\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\sx126x_driver\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_planner\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\smtc_secure_element;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\soft_secure_element;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\headers;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\alc_sync;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\file_upload;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\stream;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ral\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ralf\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal\;..\..\..\..\lora_basics_modem\printers\;..\..\..\..\shields\SX126X\common\inc;..\..\..\..\shields\SX126X\radio_drivers_hal;..\..\..\..\shields\SX126X\smtc_shield_sx126x\SX1262MB1CAS\inc;..\..\..\..\shields\SX126X\smtc_shield_sx126x\common\inc;..\..\..\..\shields\common;..\..\..\..\shields\interface;..\..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\inc;..\..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\smtc_modem_hal\;..\..\..\..\smtc_hal\board\;..\..\..\..\smtc_hal\inc\;..\..\..\..\lora_basics_modem\lora_basics_modem;..\..\..\..\shields\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target SX1262MB1CBS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: lbm_example_lorawan_asynchronous +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: as above
  c include: ..\..\..\..\apps\common;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Include;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\hal_config;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_api\;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\device_management;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_b;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_c;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\smtc_real\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_config;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_supervisor;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\sx126x_driver\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\sx126x_driver\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_planner\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\smtc_secure_element;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\soft_secure_element;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\headers;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\alc_sync;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\file_upload;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\stream;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ral\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ralf\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal\;..\..\..\..\lora_basics_modem\printers\;..\..\..\..\shields\SX126X\common\inc;..\..\..\..\shields\SX126X\radio_drivers_hal;..\..\..\..\shields\SX126X\smtc_shield_sx126x\SX1262MB1CBS\inc;..\..\..\..\shields\SX126X\smtc_shield_sx126x\common\inc;..\..\..\..\shields\common;..\..\..\..\shields\interface;..\..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\inc;..\..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\smtc_modem_hal\;..\..\..\..\smtc_hal\board\;..\..\..\..\smtc_hal\inc\;..\..\..\..\lora_basics_modem\lora_basics_modem;..\..\..\..\shields\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target SX1262MB1DAS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: lbm_example_lorawan_asynchronous +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: as above
  c include: ..\..\..\..\apps\common;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Include;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\hal_config;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_api\;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\device_management;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_b;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_c;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\smtc_real\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_config;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_supervisor;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\sx126x_driver\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\sx126x_driver\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_planner\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\smtc_secure_element;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\soft_secure_element;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\headers;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\alc_sync;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\file_upload;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\stream;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ral\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ralf\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal\;..\..\..\..\lora_basics_modem\printers\;..\..\..\..\shields\SX126X\common\inc;..\..\..\..\shields\SX126X\radio_drivers_hal;..\..\..\..\shields\SX126X\smtc_shield_sx126x\SX1262MB1DAS\inc;..\..\..\..\shields\SX126X\smtc_shield_sx126x\common\inc;..\..\..\..\shields\common;..\..\..\..\shields\interface;..\..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\inc;..\..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\smtc_modem_hal\;..\..\..\..\smtc_hal\board\;..\..\..\..\smtc_hal\inc\;..\..\..\..\lora_basics_modem\lora_basics_modem;..\..\..\..\shields\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target SX1262MB1PAS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: lbm_example_lorawan_asynchronous +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: as above
  c include: ..\..\..\..\apps\common;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Include;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\hal_config;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_api\;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\device_management;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_b;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_c;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\smtc_real\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_config;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_supervisor;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\sx126x_driver\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\sx126x_driver\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_planner\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\smtc_secure_element;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\soft_secure_element;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\headers;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\alc_sync;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\file_upload;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\stream;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ral\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ralf\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal\;..\..\..\..\lora_basics_modem\printers\;..\..\..\..\shields\SX126X\common\inc;..\..\..\..\shields\SX126X\radio_drivers_hal;..\..\..\..\shields\SX126X\smtc_shield_sx126x\SX1262MB1PAS\inc;..\..\..\..\shields\SX126X\smtc_shield_sx126x\common\inc;..\..\..\..\shields\common;..\..\..\..\shields\interface;..\..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\inc;..\..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\smtc_modem_hal\;..\..\..\..\smtc_hal\board\;..\..\..\..\smtc_hal\inc\;..\..\..\..\lora_basics_modem\lora_basics_modem;..\..\..\..\shields\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target SX1262MB2CAS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: lbm_example_lorawan_asynchronous +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: as above
  c include: ..\..\..\..\apps\common;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Include;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\hal_config;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_api\;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\device_management;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_b;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_c;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\smtc_real\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_config;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_supervisor;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\sx126x_driver\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\sx126x_driver\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_planner\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\smtc_secure_element;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\soft_secure_element;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\headers;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\alc_sync;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\file_upload;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\stream;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ral\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ralf\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal\;..\..\..\..\lora_basics_modem\printers\;..\..\..\..\shields\SX126X\common\inc;..\..\..\..\shields\SX126X\radio_drivers_hal;..\..\..\..\shields\SX126X\smtc_shield_sx126x\SX1262MB2CAS\inc;..\..\..\..\shields\SX126X\smtc_shield_sx126x\common\inc;..\..\..\..\shields\common;..\..\..\..\shields\interface;..\..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\inc;..\..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\smtc_modem_hal\;..\..\..\..\smtc_hal\board\;..\..\..\..\smtc_hal\inc\;..\..\..\..\lora_basics_modem\lora_basics_modem;..\..\..\..\shields\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target SX1268MB1GAS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: lbm_example_lorawan_asynchronous +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: as above
  c include: ..\..\..\..\apps\common;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Include;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\host_driver\STMicroelectronics\STM32L4xx\hal_config;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_api\;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\device_management;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_b;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_c;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\smtc_real\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_config;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_supervisor;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\sx126x_driver\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\sx126x_driver\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_planner\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\smtc_secure_element;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\soft_secure_element;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\headers;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\alc_sync;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\file_upload;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\stream;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ral\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ralf\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal\;..\..\..\..\lora_basics_modem\printers\;..\..\..\..\shields\SX126X\common\inc;..\..\..\..\shields\SX126X\radio_drivers_hal;..\..\..\..\shields\SX126X\smtc_shield_sx126x\SX1268MB1GAS\inc;..\..\..\..\shields\SX126X\smtc_shield_sx126x\common\inc;..\..\..\..\shields\common;..\..\..\..\shields\interface;..\..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\inc;..\..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\smtc_modem_hal\;..\..\..\..\smtc_hal\board\;..\..\..\..\smtc_hal\inc\;..\..\..\..\lora_basics_modem\lora_basics_modem;..\..\..\..\shields\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
