# Keil uVision project lbm_example_lorawan_asynchronous.uvprojx, settings and files
target lorawan_asynchronous_crypto_sw (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lbm_example_lorawan_asynchronous +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L476xx,NUCLEO_L476RG,LR1110,LR1110_TRANSCEIVER,ENABLE_MODEM_GNSS_FEATURE,REGION_CN_470,REGION_CN_470_RP_1_0,REGION_EU_868,REGION_US_915,USER_DEFINED_JOIN_PARAMETERS
  c include: ..\..\common;..\..\..\projects\LR1110\LR1110MB1LxKS\BSP\peripherals\external_supply;..\..\..\projects\LR1110\LR1110MB1LxKS\BSP\peripherals\Leds;..\..\..\projects\LR1110\LR1110MB1LxKS\BSP\peripherals\lis2de12;..\..\..\projects\LR1110\LR1110MB1LxKS\BSP\peripherals\usr_button;..\..\..\projects\LR1110\LR1110MB1LxKS\BSP\board;..\..\..\smtc_board;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ral\src;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ralf\src;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\lr1110_driver\src;..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Include;..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\host_driver\STMicroelectronics\STM32L4xx\hal_config;..\..\..\smtc_hal\inc;..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\smtc_modem_hal;..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\inc;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_api;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_config;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\device_management;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_core;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\headers;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_planner\src;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\lr1110_driver;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_api\smtc_modem_api_lr1110_extensions;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\lr1110_secure_element;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_api;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_config;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_core;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_supervisor;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\device_management;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_services;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\headers;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\stream;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\alc_sync;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\file_upload;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\almanac_update;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ralf\src;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ral\src;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\services;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_c;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_planner\src;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\smtc_secure_element;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\soft_secure_element;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\smtc_real\src;..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal;..\..\..\lora_basics_modem\lora_basics_modem\;..\..\..\projects\LR1110\radio_drivers_hal\;..\..\..\smtc_hal\board;..\..\lorawan_asynchronous
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ../../../host_driver/STMicroelectronics/STM32L4xx/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l476xx.s
  group Application/User
    ../../common/: apps_utilities.c apps_modem_common.c apps_modem_event.c
    ../: main_lorawan_asynchronous.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../host_driver/STMicroelectronics/STM32L4xx/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rng.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_lptim.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_iwdg.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../../../host_driver/STMicroelectronics/STM32L4xx/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/BSP/Components
    ../../../projects/LR1110/LR1110MB1LxKS/BSP/peripherals/external_supply/: external_supply.c
    ../../../projects/LR1110/LR1110MB1LxKS/BSP/peripherals/Leds/: leds.c
    ../../../projects/LR1110/LR1110MB1LxKS/BSP/peripherals/lis2de12/: lis2de12.c
    ../../../projects/LR1110/LR1110MB1LxKS/BSP/peripherals/usr_button/: usr_button.c
  group radio_driver
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/radio_drivers/lr1110_driver/src/: lr1110_bootloader.c lr1110_crypto_engine.c lr1110_driver_version.c lr1110_gnss.c lr1110_radio.c lr1110_regmem.c lr1110_system.c lr1110_wifi.c
  group board
    ../../../projects/LR1110/LR1110MB1LxKS/BSP/board/: lr1110_mb1lxks_board.c
  group smtc_modem_hal
    ../../../smtc_hal/STMicroelectronics/STM32L4xx/smtc_modem_hal/: smtc_modem_hal.c
  group smtc_hal
    ../../../smtc_hal/STMicroelectronics/STM32L4xx/src/: smtc_hal_adc.c smtc_hal_flash.c smtc_hal_gpio.c smtc_hal_i2c.c smtc_hal_lp_timer.c smtc_hal_mcu.c smtc_hal_rng.c smtc_hal_rtc.c smtc_hal_spi.c smtc_hal_tmr_list.c smtc_hal_trace.c smtc_hal_uart.c smtc_hal_watchdog.c
  group radio_hal
    ../../../projects/LR1110/radio_drivers_hal/: lr1110_hal.c
  group radio_ral
    ../../../projects/LR1110/LR1110MB1LxKS/BSP/ral_bsp/: ral_lr1110_bsp.c
  group smtc_modem_api
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/modem_core/: smtc_modem_api_lr1110_crypto_engine.c smtc_modem_api_lr1110_system.c
  group smtc_modem_services
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_modem_services/src/almanac_update/: almanac_update.c
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_modem_services/src/alc_sync/: alc_sync.c
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_modem_services/src/file_upload/: file_upload.c
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_modem_services/src/stream/: rose.c stream.c
  group smtc_ral
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_ral/src/: ral_lr1110.c
  group smtc_ralf
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_ralf/src/: ralf_lr1110.c
  group smtc_modem_crypto
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_modem_crypto/lr1110_secure_element/: lr1110_se.c
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_modem_crypto/: smtc_modem_crypto.c
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_modem_crypto/soft_secure_element/: aes.c cmac.c soft_se.c
  group smtc_modem_core
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/lorawan_api/: lorawan_api.c
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/device_management/: dm_downlink.c modem_context.c
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/modem_core/: smtc_modem.c smtc_modem_test.c
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/modem_services/: fifo_ctrl.c lorawan_certification.c modem_utilities.c smtc_modem_services_hal.c smtc_clock_sync.c
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/modem_supervisor/: modem_supervisor.c
  group lr1mac
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/lr1mac/src/: lr1_stack_mac_layer.c lr1mac_core.c lr1mac_utilities.c
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/lr1mac/src/smtc_real/src/: smtc_real.c
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/lr1mac/src/services/: smtc_duty_cycle.c smtc_lbt.c
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/lr1mac/src/lr1mac_class_c/: lr1mac_class_c.c
  group radio_planner
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/radio_planner/src/: radio_planner.c radio_planner_hal.c
  group smtc_region
    ../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/lr1mac/src/smtc_real/src/: region_eu_868.c region_cn_470.c region_cn_470_rp_1_0.c region_us_915.c
target lorawan_asynchronous_crypto_lr1110 (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: lbm_example_lorawan_asynchronous +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L476xx,NUCLEO_L476RG,LR1110,LR1110_TRANSCEIVER,ENABLE_MODEM_GNSS_FEATURE,REGION_CN_470,REGION_CN_470_RP_1_0,REGION_EU_868,REGION_US_915,USER_DEFINED_JOIN_PARAMETERS,USE_LR1110_SE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target lorawan_asynchronous_crypto_lr1110_with_credentials (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: lbm_example_lorawan_asynchronous +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L476xx,NUCLEO_L476RG,LR1110,LR1110_TRANSCEIVER,ENABLE_MODEM_GNSS_FEATURE,REGION_CN_470,REGION_CN_470_RP_1_0,REGION_EU_868,REGION_US_915,LR1110_DEFINED_JOIN_PARAMETERS,USE_LR1110_SE, USE_PRE_PROVISIONED_FEATURES
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
software components: CMSIS:CORE 5.4.0
